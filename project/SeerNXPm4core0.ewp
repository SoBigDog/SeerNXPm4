# IAR project SeerNXPm4core0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX7S5_M4 NXP MCIMX7S5_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0
  ICCARM.CCIncludePath2: ..\BSP; ..\CMSIS\inc; ..\User; ..\User\ErrorCode; ..\Protobuf; ..\FWlib\inc; ..\FWlib\scfw_api
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SeerNXPm4core0.bin
  ILINK.IlinkOutputFile: SeerNXPm4core0.out
  ILINK.IlinkIcfFile: MIMX8QM6xxxFF_cm4_core0_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP
    ../BSP/: BSP.c
  group CMSIS/src
    ../CMSIS/src/: system_MIMX8QM6_cm4_core0.c
  group CMSIS/Startup
    ../CMSIS/startup/: startup_MIMX8QM6_cm4_core0.s
  group FWlib
    ../FWlib/src/: fsl_asmc.c fsl_cache.c fsl_clock.c fsl_common.c fsl_dpu.c fsl_edma.c fsl_enet.c fsl_esai.c fsl_esai_edma.c fsl_flexcan.c fsl_flexcan_edma.c fsl_flexspi.c fsl_ftm.c fsl_gpio.c fsl_gpt.c fsl_intmux.c fsl_irqsteer.c fsl_isi.c fsl_ldb.c fsl_lpadc.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpit.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_mipi_csi2rx.c fsl_mipi_dsi.c fsl_mu.c fsl_rgpio.c fsl_sai.c fsl_sai_edma.c fsl_sema42.c fsl_tpm.c fsl_wdog32.c
  group FWlib/main
    ../FWlib/scfw_api/main/: ipc_imx8qm.c
  group FWlib/svc
    ../FWlib/scfw_api/svc/irq/: irq_rpc_clnt.c
    ../FWlib/scfw_api/svc/misc/: misc_rpc_clnt.c
    ../FWlib/scfw_api/svc/pad/: pad_rpc_clnt.c
    ../FWlib/scfw_api/svc/pm/: pm_rpc_clnt.c
    ../FWlib/scfw_api/svc/rm/: rm_rpc_clnt.c
    ../FWlib/scfw_api/svc/timer/: timer_rpc_clnt.c
  group User
    ../User/: main.cpp
