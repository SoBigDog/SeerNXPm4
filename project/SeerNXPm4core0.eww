<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SeerNXPm4core0.ewp</path>
    </project>
    <batchBuild />
</workspace>
